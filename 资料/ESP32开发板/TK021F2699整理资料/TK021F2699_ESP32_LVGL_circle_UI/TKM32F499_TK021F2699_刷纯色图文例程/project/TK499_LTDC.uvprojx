# Keil uVision project TK499_LTDC.uvprojx, settings and files
target TK499_LTDC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: TK499_LTDC +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..//@L.bin  ./obj/@L.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\CMSIS_and_startup;..\CMSIS_and_startup\CMSIS;.\bsp;..\Hal_lib\inc;.\bsp\LCD;.\bsp\LED;.\bsp\SPI;.\bsp\sys;.\bsp\UART;.\bsp\Timer
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
  group startup
    ../CMSIS_and_startup/: startup_Tk499.s tk499.h sys.c
    ./: readme.txt
  group bsp
    ./bsp/: main.c
    ./bsp/LCD/: LCD.c
    ./bsp/Timer/: timer.c
    ./bsp/UART/: UART.c
  group hal_lib
    ../Hal_lib/src/: HAL_gpio.c HAL_rcc.c HAL_tim.c HAL_exti.c HAL_misc.c HAL_uart.c HAL_spi.c
